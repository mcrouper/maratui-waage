# Creo Parametric part "SHAPESTRING090_1", saved by Creo 12 (build 12.4.2.0) (file shapestring090_1.prt.1)
Units: Custom; MM, KILOGRAM, SECS

Parameters:
  PTC_WM_ITERATION = "0"
  PTC_WM_VERSION = "-.0"
  PTC_WM_LIFECYCLE_STATE = "In Work"
  PTC_WM_LIFECYCLE = "MO_CADDocument"
  PTC_WM_CREATED_BY = "Maximilian Roepper (Z0017RMS: MO)"
  PTC_WM_CREATED_ON = "18-Sep-26 11:36:42 AM"
  PTC_WM_MODIFIED_BY = "Maximilian Roepper (Z0017RMS: MO)"
  PTC_WM_MODIFIED_ON = "18-Sep-26 11:36:46 AM"
  PDMLINKNUMBER = "PDM000071455203"
  PTC_WM_NAME = "shapestring090_1.prt"
  PTC_WM_NUMBER = "PDM000071455203"

Other parameters: WEIGHT, WEIGHT_FACTOR, WEIGHT_ADD, _MASS_TEMP, _DIFF_TEMP, MC_ERRORS, SUPPLIER

Features:
  1. coordinate system
  2. datum plane "PRT_YZ"
  3. datum plane "PRT_XY"
  4. datum plane "PRT_XZ"
  5. coordinate system
  6. datum axis
  7. datum axis
  8. datum axis
  9. coordinate system
  10. imported feature
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
Other named items: PRT, SIEMENS_MO, DRW_VIEW_ORG, PRT_X, PRT_Y, PRT_Z, CS0, ROUGH_GROB

Layers: 00_STD_CSYS-KSYS, 01_STD_PLANES-EBENEN, 02_STD_AXES-ACHSEN, 03_STD_CSYS-KSYS, 24_IMPORT_FEAT-IMPORT_KE, INTFCLR

Surfaces: 1 plane