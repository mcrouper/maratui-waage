# Creo Parametric part "00000000000_-_DISPLAY_HALT_SKEL", saved by Creo 12 (build 12.4.2.0) (file 00000000000_-_display_halt_skel.prt.1)
Units: Custom; MM, KILOGRAM, SECS
Materials in the file: NOT_DEFINED

Parameters:
  PTC_MATERIAL_NAME = "NOT_DEFINED"
  PTC_WM_ITERATION = "0"
  PTC_WM_VERSION = "-.0"
  PTC_WM_LIFECYCLE_STATE = "In Work"
  PTC_WM_LIFECYCLE = "MO_CADDocument"
  PTC_WM_LOCATION = "/Libraries/ProE_Standards/templates/rolling_stock"
  PTC_WM_CREATED_BY = "Maximilian Roepper (Z0017RMS: MO)"
  PTC_WM_CREATED_ON = "18-Sep-26 11:36:42 AM"
  PTC_WM_MODIFIED_BY = "Maximilian Roepper (Z0017RMS: MO)"
  PTC_WM_MODIFIED_ON = "02-Oct-26 01:21:57 PM"
  PDMLINKNUMBER = "PDM000071455160"
  PTC_WM_NAME = "00000000000_-_display_halt_skel.prt"
  PTC_WM_NUMBER = "PDM000071455160"
  PRO_UNIT_SYS = "Custom"

Other parameters: WEIGHT, WEIGHT_FACTOR, WEIGHT_ADD, MC_ERRORS, SUPPLIER

Features:
  1. coordinate system
  2. datum plane "REF_YZ"
  3. datum plane "REF_XY"
  4. datum plane "REF_XZ"
  5. coordinate system
  6. datum axis
  7. datum axis
  8. datum axis
  9. coordinate system
  10. datum plane "DTM1"

Other named items: REF, SIEMENS_MO, KOS_DECKEL, REF_X, REF_Y, REF_Z, CS0, ROUGH_GROB

Layers: 00_STD_CSYS-KSYS, 01_STD_PLANES-EBENEN, 02_STD_AXES-ACHSEN, 03_STD_CSYS-KSYS, 04_PLANES-EBENEN, 06_CSYS-KSYS